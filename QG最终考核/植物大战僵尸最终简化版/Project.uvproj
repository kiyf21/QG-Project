# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c pubilc.c pubilc.h menu.c menu.h LCD12864.c LCD12864.h Delay.c Delay.h MatrixKey.c MatrixKey.h game.c game.h area.c area.h player.c player.h bullet.c bullet.h Timer0.c Timer0.h zombie.c zombie.h blood.c blood.h settlement.c settlement.h score.c score.h AT24C02.c AT24C02.h I2C.c I2C.h
