# Keil uVision project IIC_Menu_12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: IIC_Menu_12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c public.c public.h lcd12864.c lcd12864.h uart.c uart.h timer.c timer.h menu.c menu.h menu2.c menu3.c ds1302.c ds1302.h
